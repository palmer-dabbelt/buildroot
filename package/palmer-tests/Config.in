## package/palmer-tests/Config.in
```kconfig
config BR2_PACKAGE_PALMER_TESTS
	bool "palmer_tests"
	default y
	help
	  Palmer's tests
```
